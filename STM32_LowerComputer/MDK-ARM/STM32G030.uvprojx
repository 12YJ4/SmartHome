# Keil uVision project STM32G030.uvprojx, settings and files
target STM32G030 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G030C8Tx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STM32G030 +hex
  AfterMake: fromelf.exe --bin !L --output ./bin/WiFi-Client.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G030xx
  c include: ../Inc;                              ../Drivers/STM32G0xx_HAL_Driver/Inc;                              ../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;                              ../Drivers/CMSIS/Device/ST/STM32G0xx/Include;                              ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32g030xx.s
  group Application/User
    ../Src/: main.c gpio.c adc.c dma.c tim.c usart.c stm32g0xx_it.c stm32g0xx_hal_msp.c key.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_gpio.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_ll_adc.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group Function
    ../Src/: fs_crc.c fs_protocol.c bsp_esp8266.c bsp_lcd.c bsp_P9813.c bsp_softwareTimer.c bsp_ultrasonic.c app_system.c bsp_beep.c hanzi.c fan_relay.c dht11.c bsp_delay.c
software components: CMSIS:CORE 4.3.0
